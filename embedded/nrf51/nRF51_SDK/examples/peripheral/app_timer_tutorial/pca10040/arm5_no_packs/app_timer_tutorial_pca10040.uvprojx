# Keil uVision project app_timer_tutorial_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 DEBUG
  c misc: --c99
  c include: ..\..\config\pca10040;..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\drivers_nrf\delay
  asm define: BSP_DEFINES_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c app_error_weak.c app_util_platform.c
    ../../../../../components/libraries/timer/: app_timer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
